File: ESP8266.sch (KiCad schematic (older format))
At the start: 35 parts

Commit message: update,
Other:
- moved on the sheet: C?, D?, F?, R?, U?
